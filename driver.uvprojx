# Keil uVision project driver.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32G431MBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, CMSIS:NN Lib 1.1.0, Compiler:Event Recorder 1.4.0, File System:CORE 6.10.1, Device:STM32Cube HAL 1.4.0, Device:Startup 1.4.0, CMSIS Driver:I2C:Multi-Slave 1.0.1, CMSIS Driver:SPI 1.1.0, CMSIS Driver:SPI:Multi-Slave 1.0.1, CMSIS Driver:USART 1.0.0
